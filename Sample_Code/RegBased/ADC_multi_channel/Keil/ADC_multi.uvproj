# Keil uVision project ADC_multi.uvproj, settings and files
target ADC (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ADC_Multi +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Include
  group Source Group 1
    ./Code/: ADC.C
  group Common
    ../../../Library/StdDriver/src/: sys.c uart.c
  group Startup
    ../../../Library/Startup/Keil/: STARTUP.A51
