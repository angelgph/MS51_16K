# Keil uVision project FSYS_MHIRC.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: IAP_MHIRC +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: FSYS_MHIRC.C
  group Library
    ../../../../Library/StdDriver/src/: sys.c delay.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
