# Keil uVision project I2C_EEPROM.uvproj, settings and files
target I2C_EEPROM (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: I2C_EEPROM +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: I2C_EEPROM.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c delay.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
