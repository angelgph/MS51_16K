# Keil uVision project IAP_APproLD.uvproj, settings and files
target ISP_AP-AP (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: IAP_APproLD +hex
  AfterMake: ..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Include
  group Source Group 1
    ./Code/: IAP_APproLD.c
  group Common
    ../../../Library/StdDriver/src/: Delay.c sys.c
  group Startup
    ../../../Library/Startup/Keil/: STARTUP.A51
