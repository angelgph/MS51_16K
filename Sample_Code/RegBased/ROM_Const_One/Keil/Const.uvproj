# Keil uVision project Const.uvproj, settings and files
target Const (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: CONST +hex
  AfterMake: ..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Include
  group Source Group 1
    ./Code/: CONST.C
  group Common
    ../../../Library/StdDriver/src/: Delay.c sys.c
  group Startup
    ../../../Library/Startup/Keil/: STARTUP.A51
